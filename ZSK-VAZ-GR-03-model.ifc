Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:17:09+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-VAZ-GR-03
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Изделие бетонное благоустройства, ZSK-VAZ-GR-03 Вазон «Саиф» · чёрный гранит
In: Площадка
Description: Изделие бетонное благоустройства. Вазон «Саиф» · чёрный гранит; Classification: 05.3.02.03 Вазон уличный (Классификатор строительных ресурсов (КСР)); Material: Железобетон
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-VAZ-GR-03; ModelReference: Вазон «Саиф» · чёрный гранит; ProductionYear: 2026; ArticleNumber: ZSK-VAZ-GR-03
ORION_Изделие - Артикул: ZSK-VAZ-GR-03; Артикул прежний: SD-VAZ-GR-03; Наименование: Вазон «Саиф» · чёрный гранит; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 400×400×400 мм; Материал: Железобетон; Цена: 32 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/concrete/20303; Код КСИ: CPr>EDG010; Класс КСИ: Вазон уличный; Коды КСР: 05.3.02.03 … 59.1.15.02-0449
ADSK - ADSK_Наименование: Вазон «Саиф» · чёрный гранит; ADSK_Марка: ZSK-VAZ-GR-03; ADSK_Код изделия: 05.3.02.03; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Железобетон; ADSK_URL страницы изделия: https://зск.рф/catalog/concrete/20303
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDG010; ZSK_Артикул_прежний: SD-VAZ-GR-03
Qto_ORION - Длина: 400 mm; Ширина: 400 mm; Высота: 400 mm
